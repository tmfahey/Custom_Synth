# IAR project interface_module.ewp, settings and files
configuration interface_module (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030R8 ST STM32F030R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: interface_module.out
  ILINK.IlinkIcfFile: stm32f030x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Application/EWARM
    ./:  startup_stm32f030x8.s
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ./: 
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c
